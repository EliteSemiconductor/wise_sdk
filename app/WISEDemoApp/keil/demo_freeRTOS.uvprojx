# Keil uVision project demo_freeRTOS.uvprojx, settings and files
target demo_freeRTOS (6240000::V6.24::ARMCLANG)
  device: ER8131P9 ESMT
  pack: ESMT.ER813x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20008000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo_freeRTOS
  AfterMake: fromelf --bin --output .\Objects\demo_freeRTOS\demo_freeRTOS.bin .\Objects\demo_freeRTOS\demo_freeRTOS.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __STACK_SIZE=0x800, __HEAP_SIZE=0x4000, PLATFORM_COMPONENTS_FILE=\"components_demo_rtos.h\", TARGET_APP
  c misc: -std=gnu11 -fno-short-wchar -Wno-error=implicit-function-declaration -Wno-error=int-conversion -Wno-error=incompatible-function-pointer-types
  c include: ..\config;..\src;..\src\demo_boot_loader;..\src\demo_cli;..\src\demo_crypto;..\src\demo_flash;..\src\demo_freeRTOS;..\src\demo_gpio;..\src\demo_gptmr;..\src\demo_i2c;..\src\demo_nfc;..\src\demo_pio;..\src\demo_power_mode;..\src\demo_pwm;..\src\demo_pwmslow;..\src\demo_radio_trx;..\src\demo_rtc;..\src\demo_spi;..\src\demo_template;..\src\demo_timer_hub;..\src\demo_trng;..\src\demo_wdt;..\src\demo_wmbus;..\src\demo_wmbus_link;..\src\demo_wutmr;..\..\..\boards;..\..\..\middleware;..\..\..\middleware\wise_system;..\..\..\middleware\retarget;..\..\..\middleware\wise_shell_v2;..\..\..\middleware\wise_shell_v2\src;..\..\..\middleware\wise_shell_v2\intf;..\..\..\middleware\wise_timer_hub;..\..\..\middleware\wise_wmbus_crypto;..\..\..\middleware\wise_kermit;..\..\..\middleware\wise_flash_filesystem;..\..\..\middleware\wise_nvm;..\..\..\wise_core_v2;..\..\..\wise_core_v2\api;..\..\..\wise_core_v2\core_utils;..\..\..\wise_core_v2\platform\hal_intf;..\..\..\wise_core_v2\platform\er8131p9;..\..\..\wise_core_v2\platform\er8131p9\arm_core;..\..\..\wise_core_v2\radio_lib;..\..\..\wise_core_v2\radio_lib\er8131p9;..\..\..\third_party\FreeRTOS-Kernel\include;..\..\..\third_party\FreeRTOS-Kernel\portable\GCC\ARM_CM3;..\..\..\third_party\mbedtls\include;..\..\..\third_party\mbedtls\configs;..\..\..\protocol\wmbus_datalink;..\..\..\protocol\wmbus_datalink\platform_intf
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
  scatter file: .\er8130_9006.sct
  link misc: ..\..\..\wise_core_v2\prebuilt_libs\libWISERadioLib_er8131p9.a --diag_suppress=6314
  group boards
    ../../../boards/: board_default_cfg.h
  group config
    ../config/: components_demo_app.h components_demo_crypto.h components_demo_loader.h components_demo_rtos.h components_demo_simple.h components_demo_timer_hub.h components_demo_wmbus.h components_demo_wutmr.h
  group src
    ../src/: app_shell_commands.c demo_app_common.c
  group middleware/retarget
    ../../../middleware/retarget/: retarget.c
  group middleware/wise_system
    ../../../middleware/wise_system/: wise_common.c wise_event.c wise_schlr.c
  group middleware/wise_shell_v2/src
    ../../../middleware/wise_shell_v2/src/: cmdhist.c shell.c shell_cmd.c shell_complete.c shell_input.c shell_render.c
  group middleware/wise_shell_v2/intf
    ../../../middleware/wise_shell_v2/intf/: intf_shell.c
  group wise_core_v2/api
    ../../../wise_core_v2/api/: wise_core.c wise_crypto_api.c wise_efuse_api.c wise_flash_api.c wise_gpio_api.c wise_gptmr_api.c wise_i2c_api.c wise_nfc_api.c wise_pmu_api.c wise_pwm_api.c wise_pwmslow_api.c wise_rtc_api.c wise_spi_api.c wise_sys_api.c wise_tick_api.c wise_trng_api.c wise_uart_api.c wise_wdt_api.c wise_wutmr_api.c wise_xcvr_api.c
  group wise_core_v2/core_utils
    ../../../wise_core_v2/core_utils/: util.c util_debug_log.c wise_fifo.c
  group wise_core_v2/platform/hal_intf
    ../../../wise_core_v2/platform/hal_intf/: hal_intf_cache.c hal_intf_crypto.c hal_intf_dma.c hal_intf_efuse.c hal_intf_extpmu.c hal_intf_flash.c hal_intf_gpio.c hal_intf_gptmr.c hal_intf_i2c.c hal_intf_nfc.c hal_intf_pio.c hal_intf_pmu.c hal_intf_pwm.c hal_intf_pwmslow.c hal_intf_rtc.c hal_intf_spi.c hal_intf_sys.c hal_intf_trng.c hal_intf_uart.c hal_intf_wdt.c hal_intf_wutmr.c
  group wise_core_v2/platform/er8131p9/arm_core
    ../../../wise_core_v2/platform/er8131p9/arm_core/cmsis/esmt/Source/: startup_er81xx.c system_er81xx.c
  group wise_core_v2/platform/er8131p9/drv
    ../../../wise_core_v2/platform/er8131p9/drv/: hal_drv_aes.c hal_drv_cache.c hal_drv_dma.c hal_drv_efuse.c hal_drv_extpmu.c hal_drv_flash.c hal_drv_gpio.c hal_drv_gptmr.c hal_drv_i2c.c hal_drv_nfc.c hal_drv_pio.c hal_drv_pmu.c hal_drv_pwm.c hal_drv_pwmslow.c hal_drv_rtc.c hal_drv_sha.c hal_drv_spi.c hal_drv_sys.c hal_drv_trng.c hal_drv_uart.c hal_drv_wdt.c hal_drv_wutmr.c
  group wise_core_v2/platform/er8131p9/hdl
    ../../../wise_core_v2/platform/er8131p9/hdl/: aes_er8130.c cache_er8130.c dma_er8130.c efuse_er8130.c extpmu_er8130.c flctl_er8130.c gpio_er8130.c gptmr_er8130.c i2c_er8130.c nfc_er8130.c pio_er8130.c pmu_er8130.c pwm_er8130.c pwmslow_er8130.c rtc_er8130.c sha_er8130.c spi_er8130.c sys_er8130.c trng_er8130.c uart_er8130.c wdt_er8130.c wutmr_er8130.c
  group src/demo_freeRTOS
    ../src/demo_freeRTOS/: demo_freeRTOS_main.c
  group third_party/FreeRTOS-Kernel
    ../../../third_party/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group third_party/FreeRTOS-Kernel/port
    ../../../third_party/FreeRTOS-Kernel/portable/GCC/ARM_CM3/: port.c
    ../../../third_party/FreeRTOS-Kernel/platform/: tick_control.c
  group third_party/FreeRTOS-Kernel/heap
    ../../../third_party/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
