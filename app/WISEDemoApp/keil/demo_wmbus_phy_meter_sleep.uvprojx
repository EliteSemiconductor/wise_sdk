# Keil uVision project demo_wmbus_phy_meter_sleep.uvprojx, settings and files
target demo_wmbus_phy_meter_sleep (6240000::V6.24::ARMCLANG)
  device: ER8131P9 ESMT
  pack: ESMT.ER813x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20008000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo_wmbus_phy_meter_sleep
  AfterMake: fromelf --bin --output .\Objects\demo_wmbus_phy_meter_sleep\demo_wmbus_phy_meter_sleep.bin .\Objects\demo_wmbus_phy_meter_sleep\demo_wmbus_phy_meter_sleep.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __STACK_SIZE=0x800, __HEAP_SIZE=0x4000, TARGET_APP, WISE_WMBUS_SW_HELPER, WISE_LOG_LEVEL=2, WMBUS_DEMO_PHY_METER_PD, PLATFORM_COMPONENTS_FILE=\"components_demo_wmbus.h\"
  c misc: -std=gnu11 -fno-short-wchar -Wno-error=implicit-function-declaration -Wno-error=int-conversion -Wno-error=incompatible-function-pointer-types
  c include: ..\config;..\src;..\src\demo_boot_loader;..\src\demo_cli;..\src\demo_crypto;..\src\demo_flash;..\src\demo_freeRTOS;..\src\demo_gpio;..\src\demo_gptmr;..\src\demo_i2c;..\src\demo_nfc;..\src\demo_pio;..\src\demo_power_mode;..\src\demo_pwm;..\src\demo_pwmslow;..\src\demo_radio_trx;..\src\demo_rtc;..\src\demo_spi;..\src\demo_template;..\src\demo_timer_hub;..\src\demo_trng;..\src\demo_wdt;..\src\demo_wmbus;..\src\demo_wmbus_link;..\src\demo_wutmr;..\..\..\boards;..\..\..\middleware;..\..\..\middleware\wise_system;..\..\..\middleware\retarget;..\..\..\middleware\wise_shell_v2;..\..\..\middleware\wise_shell_v2\src;..\..\..\middleware\wise_shell_v2\intf;..\..\..\middleware\wise_timer_hub;..\..\..\middleware\wise_wmbus_crypto;..\..\..\middleware\wise_kermit;..\..\..\middleware\wise_flash_filesystem;..\..\..\middleware\wise_nvm;..\..\..\wise_core_v2;..\..\..\wise_core_v2\api;..\..\..\wise_core_v2\core_utils;..\..\..\wise_core_v2\platform\hal_intf;..\..\..\wise_core_v2\platform\er8131p9;..\..\..\wise_core_v2\platform\er8131p9\arm_core;..\..\..\wise_core_v2\radio_lib;..\..\..\wise_core_v2\radio_lib\er8131p9;..\..\..\third_party\FreeRTOS-Kernel\include;..\..\..\third_party\FreeRTOS-Kernel\portable\GCC\ARM_CM3;..\..\..\third_party\mbedtls\include;..\..\..\third_party\mbedtls\configs;..\..\..\protocol\wmbus_datalink;..\..\..\protocol\wmbus_datalink\platform_intf
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
  scatter file: .\er8130_9006.sct
  link misc: ..\..\..\wise_core_v2\prebuilt_libs\libWISERadioLib_er8131p9.a ..\..\..\protocol\prebuilt_libs\libWMbusDatalink.a --diag_suppress=6314
  group boards
    ../../../boards/: board_b402_cfg.h board_ble_soc_a002_cfg.h board_default_cfg.h board_er8130tc01_arduino.h board_er8130tc01_dbg.h board_er8130tc01_dbg_cfg_460800.h board_m2c_es22.h board_m2c_es22_115200.h board_soc_tc04_cfg.h
  group config
    ../config/: components_demo_app.h components_demo_crypto.h components_demo_loader.h components_demo_rtos.h components_demo_simple.h components_demo_timer_hub.h components_demo_wmbus.h components_demo_wutmr.h
  group src
    ../src/: app_shell_commands.c demo_app_common.c
  group middleware/retarget
    ../../../middleware/retarget/: retarget.c
  group middleware/wise_system
    ../../../middleware/wise_system/: wise_common.c wise_event.c wise_schlr.c
  group middleware/wise_shell_v2/src
    ../../../middleware/wise_shell_v2/src/: cmdhist.c shell.c shell_cmd.c shell_complete.c shell_input.c shell_render.c
  group middleware/wise_shell_v2/intf
    ../../../middleware/wise_shell_v2/intf/: intf_shell.c
  group wise_core_v2/api
    ../../../wise_core_v2/api/: wise_core.c wise_crypto_api.c wise_efuse_api.c wise_flash_api.c wise_gpio_api.c wise_gptmr_api.c wise_i2c_api.c wise_nfc_api.c wise_pmu_api.c wise_pwm_api.c wise_pwmslow_api.c wise_rtc_api.c wise_spi_api.c wise_sys_api.c wise_tick_api.c wise_trng_api.c wise_uart_api.c wise_wdt_api.c wise_wutmr_api.c wise_xcvr_api.c
  group wise_core_v2/core_utils
    ../../../wise_core_v2/core_utils/: util.c util_debug_log.c wise_fifo.c
  group wise_core_v2/platform/hal_intf
    ../../../wise_core_v2/platform/hal_intf/: hal_intf_cache.c hal_intf_crypto.c hal_intf_dma.c hal_intf_efuse.c hal_intf_extpmu.c hal_intf_flash.c hal_intf_gpio.c hal_intf_gptmr.c hal_intf_i2c.c hal_intf_nfc.c hal_intf_pio.c hal_intf_pmu.c hal_intf_pwm.c hal_intf_pwmslow.c hal_intf_rtc.c hal_intf_spi.c hal_intf_sys.c hal_intf_trng.c hal_intf_uart.c hal_intf_wdt.c hal_intf_wutmr.c
  group wise_core_v2/platform/er8131p9/arm_core
    ../../../wise_core_v2/platform/er8131p9/arm_core/cmsis/esmt/Source/: startup_er81xx.c system_er81xx.c
  group wise_core_v2/platform/er8131p9/drv
    ../../../wise_core_v2/platform/er8131p9/drv/: hal_drv_aes.c hal_drv_cache.c hal_drv_dma.c hal_drv_efuse.c hal_drv_extpmu.c hal_drv_flash.c hal_drv_gpio.c hal_drv_gptmr.c hal_drv_i2c.c hal_drv_nfc.c hal_drv_pio.c hal_drv_pmu.c hal_drv_pwm.c hal_drv_pwmslow.c hal_drv_rtc.c hal_drv_sha.c hal_drv_spi.c hal_drv_sys.c hal_drv_trng.c hal_drv_uart.c hal_drv_wdt.c hal_drv_wutmr.c
  group wise_core_v2/platform/er8131p9/hdl
    ../../../wise_core_v2/platform/er8131p9/hdl/: aes_er8130.c cache_er8130.c dma_er8130.c efuse_er8130.c extpmu_er8130.c flctl_er8130.c gpio_er8130.c gptmr_er8130.c i2c_er8130.c nfc_er8130.c pio_er8130.c pmu_er8130.c pwm_er8130.c pwmslow_er8130.c rtc_er8130.c sha_er8130.c spi_er8130.c sys_er8130.c trng_er8130.c uart_er8130.c wdt_er8130.c wutmr_er8130.c
  group src/demo_wmbus
    ../src/demo_wmbus/: demo_wmbus.c wmbus_helper.c
  group middleware/wise_wmbus_crypto
    ../../../middleware/wise_wmbus_crypto/: wise_wmbus_crypto.c
  group middleware/wise_kermit
    ../../../middleware/wise_kermit/: kermit.c wise_kermit.c
  group middleware/wise_flash_filesystem
    ../../../middleware/wise_flash_filesystem/: wise_file_system.c
  group middleware/wise_nvm
    ../../../middleware/wise_nvm/: wise_nvm.c wise_nvm_api.c
  group third_party/mbedtls/library
    ../../../third_party/mbedtls/library/: aes.c aesce.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c bignum_core.c bignum_mod.c bignum_mod_raw.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_curves_new.c entropy.c entropy_poll.c error.c gcm.c hkdf.c hmac_drbg.c lmots.c lms.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkcs7.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers_no_static.c psa_crypto_ecp.c psa_crypto_ffdh.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_pake.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c psa_util.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha256.c sha3.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_client.c ssl_cookie.c ssl_debug_helpers_generated.c ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_keys.c ssl_tls13_server.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write.c x509write_crt.c x509write_csr.c
