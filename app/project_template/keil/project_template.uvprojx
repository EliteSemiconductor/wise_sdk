# Keil uVision project project_template.uvprojx, settings and files
target project_template (6240000::V6.24::ARMCLANG)
  device: ER8131P9 ESMT
  pack: ESMT.ER813x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20008000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project_template
  AfterMake: fromelf --bin --output .\Objects\project_template.bin .\Objects\project_template.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __STACK_SIZE=0x1000, __HEAP_SIZE=0x4000, PLATFORM_COMPONENTS_FILE=\"components_template.h\", TARGET_APP
  c misc: -std=gnu11
  c include: ..\config;..\src;..\..\..\boards;..\..\..\middleware\wise_system;..\..\..\middleware\retarget;..\..\..\wise_core_v2;..\..\..\wise_core_v2\api;..\..\..\wise_core_v2\core_utils;..\..\..\wise_core_v2\platform\hal_intf;..\..\..\wise_core_v2\platform\er8131p9;..\..\..\wise_core_v2\platform\er8131p9\arm_core;..\..\..\wise_core_v2\radio_lib;..\..\..\wise_core_v2\radio_lib\er8131p9
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
  scatter file: .\er8130_9006.sct
  link misc: ..\..\..\wise_core_v2\prebuilt_libs\libWISERadioLib_er8131p9.a --diag_suppress=6314
  group src
    ../src/: main.c
  group middleware/retarget
    ../../../middleware/retarget/: retarget.c
  group middleware/wise_system
    ../../../middleware/wise_system/: wise_common.c wise_event.c wise_schlr.c
  group wise_core_v2/api
    ../../../wise_core_v2/api/: wise_core.c wise_crypto_api.c wise_efuse_api.c wise_flash_api.c wise_gpio_api.c wise_gptmr_api.c wise_i2c_api.c wise_nfc_api.c wise_pmu_api.c wise_pwm_api.c wise_pwmslow_api.c wise_rtc_api.c wise_spi_api.c wise_sys_api.c wise_tick_api.c wise_trng_api.c wise_uart_api.c wise_wdt_api.c wise_wutmr_api.c wise_xcvr_api.c
  group wise_core_v2/core_utils
    ../../../wise_core_v2/core_utils/: util.c util_debug_log.c wise_fifo.c
  group wise_core_v2/platform/hal_intf
    ../../../wise_core_v2/platform/hal_intf/: hal_intf_cache.c hal_intf_crypto.c hal_intf_dma.c hal_intf_efuse.c hal_intf_extpmu.c hal_intf_flash.c hal_intf_gpio.c hal_intf_gptmr.c hal_intf_i2c.c hal_intf_nfc.c hal_intf_pio.c hal_intf_pmu.c hal_intf_pwm.c hal_intf_pwmslow.c hal_intf_rtc.c hal_intf_spi.c hal_intf_sys.c hal_intf_trng.c hal_intf_uart.c hal_intf_wdt.c hal_intf_wutmr.c
  group wise_core_v2/platform/er8131p9/arm_core
    ../../../wise_core_v2/platform/er8131p9/arm_core/cmsis/esmt/Source/: startup_er81xx.c system_er81xx.c
  group wise_core_v2/platform/er8131p9/drv
    ../../../wise_core_v2/platform/er8131p9/drv/: hal_drv_aes.c hal_drv_cache.c hal_drv_dma.c hal_drv_efuse.c hal_drv_extpmu.c hal_drv_flash.c hal_drv_gpio.c hal_drv_gptmr.c hal_drv_i2c.c hal_drv_nfc.c hal_drv_pio.c hal_drv_pmu.c hal_drv_pwm.c hal_drv_pwmslow.c hal_drv_rtc.c hal_drv_sha.c hal_drv_spi.c hal_drv_sys.c hal_drv_trng.c hal_drv_uart.c hal_drv_wdt.c hal_drv_wutmr.c
  group wise_core_v2/platform/er8131p9/hdl
    ../../../wise_core_v2/platform/er8131p9/hdl/: aes_er8130.c cache_er8130.c dma_er8130.c efuse_er8130.c extpmu_er8130.c flctl_er8130.c gpio_er8130.c gptmr_er8130.c i2c_er8130.c nfc_er8130.c pio_er8130.c pmu_er8130.c pwm_er8130.c pwmslow_er8130.c rtc_er8130.c sha_er8130.c spi_er8130.c sys_er8130.c trng_er8130.c uart_er8130.c wdt_er8130.c wutmr_er8130.c
  group wise_core_v2/radio_lib
    ../../../wise_core_v2/radio_lib/: hal_drv_radio_weak.c hal_intf_radio.c rf_fmt_log.c util_bitstream_codec.c util_crc.c wise_radio_802154_api.c wise_radio_api.c wise_radio_ble_api.c wise_radio_wmbus_api.c wmbus_parameters.c
  group wise_core_v2/radio_lib/er8131p9
    ../../../wise_core_v2/radio_lib/er8131p9/: ana_er8130.c bbp_er8130.c hal_drv_radio.c mac_er8130.c modem_config.c
